# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/ioLibrary_Driver/Ethernet;../User/ioLibrary_Driver/Ethernet/W5500;..\User\ioLibrary_Driver\Ethernet\W5100S;../User/ioLibrary_Driver/Internet/DHCP;..\User\ioLibrary_Driver\Internet\DNS;..\User\ioLibrary_Driver\Internet\MQTT;..\User\ioLibrary_Driver\Internet\MQTT\MQTTPacket\src;..\User\DNS;..\User\MQTT;..\User\CJSON;..\User\user_main;..\User\wiz_interface;..\User\wiz_platform
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Ethernet
    ../User/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../User/ioLibrary_Driver/Ethernet/W5500/: w5500.c
  group Internet
    ../User/ioLibrary_Driver/Internet/DHCP/: dhcp.c
    ../User/ioLibrary_Driver/Internet/DNS/: dns.c
    ../User/ioLibrary_Driver/Internet/MQTT/: mqtt_interface.c MQTTClient.c
    ../User/ioLibrary_Driver/Internet/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group User
    ../User/CJSON/: cJSON.c
    ../User/DNS/: do_dns.c
    ../User/MQTT/: do_mqtt.c
    ../User/user_main/: user_main.c
    ../User/wiz_interface/: wiz_interface.c
    ../User/wiz_platform/: wiz_platform.c
software components: CMSIS:CORE 4.3.0
